options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: test
    output_language: python
    run_options: run
  states: {}

blocks:
- name: rx_freq1
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1000'
    stop: '62500000'
    value: '10000000'
    widget: counter
  states: {}
- name: rx_freq2
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1000'
    stop: '62500000'
    value: '10000000'
    widget: counter
  states: {}
- name: rx_rate
  id: variable
  parameters:
    value: '3125000'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '1'
    quad_rate: rx_rate
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_deinterleave_0
  id: blocks_deinterleave
  parameters:
    type: complex
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '90000'
    decim: '1'
    gain: '1'
    samp_rate: rx_rate
    type: fir_filter_ccf
    width: '10000'
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: rx_rate
    fc: rx_freq1
    fftsize: '4096'
    grid: 'True'
    gui_hint: 1,0,1,1
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: rx_rate
    fc: rx_freq2
    fftsize: '4096'
    grid: 'True'
    gui_hint: 1,1,1,1
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '3125'
    interp: '48'
    taps: ''
    type: fff
  states: {}
- name: red_pitaya_source_0
  id: red_pitaya_source
  parameters:
    addr: 192.168.1.100
    corr: '0'
    freq1: '10000000'
    freq2: '10000000'
    port: '1001'
    rate: rx_rate
  states: {}

connections:
- [analog_wfm_rcv_0, '0', rational_resampler_xxx_0, '0']
- [blocks_deinterleave_0, '0', low_pass_filter_0, '0']
- [blocks_deinterleave_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_deinterleave_0, '1', qtgui_freq_sink_x_0_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [rational_resampler_xxx_0, '0', audio_sink_0, '0']
- [red_pitaya_source_0, '0', blocks_deinterleave_0, '0']

metadata:
  file_format: 1
