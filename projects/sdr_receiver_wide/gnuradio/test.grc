options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: test
    output_language: python
    run_options: run
  states: {}

blocks:
- name: rx_freq1
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    start: '80'
    step: '0.1'
    stop: '120'
    value: '100.0'
    widget: counter
  states: {}
- name: rx_freq2
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    start: '80'
    step: '0.1'
    stop: '120'
    value: '100.0'
    widget: counter
  states: {}
- name: rx_rate
  id: variable
  parameters:
    value: '5208333'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: rx_rate
    fc: '100'
    fftsize: '1024'
    showrf: 'True'
    type: complex
    wintype: window.WIN_BLACKMAN
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    size: '1024'
    srate: rx_rate
    type: complex
  states: {}
- name: red_pitaya_source_0
  id: red_pitaya_source
  parameters:
    addr: 10.42.0.213
    attu: '0'
    corr: '0'
    freq: '1320000'
    pga: '0'
    port: '1001'
    rate: rx_rate
  states: {}

connections:
- [red_pitaya_source_0, '0', qtgui_sink_x_0, '0']
- [red_pitaya_source_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
